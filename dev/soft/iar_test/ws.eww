<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\first.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\sensor\sensor.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\stm8l_tests\tests.ewp</path>
    </project>
    <batchBuild />
</workspace>
